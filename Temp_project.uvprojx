# Keil uVision project Temp_project.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F429VITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Temp_project
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F429VITx/STCubeGenerated/Src/: main.c stm32f4xx_it.c
    ./RTE/Device/STM32F429VITx/STCubeGenerated/Inc/: stm32f4xx_it.h
software components: RTOS:Config 10.4.6, RTOS:Core 10.4.6, RTOS:Event Groups 10.4.6, RTOS:Heap 10.4.6, RTOS:Timers 10.4.6, CMSIS:CORE 5.5.0, CMSIS:RTOS2:FreeRTOS 10.4.6, Compiler:Event Recorder 1.4.0, Compiler:I/O:File 1.2.0, File System:CORE 6.14.1, File System:Drive:NAND 6.14.1, CMSIS Driver:NAND:Memory Bus 1.1.0, Device:STM32Cube HAL:Common 1.7.13, Device:STM32Cube HAL:Cortex 1.7.13, Device:STM32Cube HAL:DMA 1.7.13, Device:STM32Cube HAL:GPIO 1.7.13, Device:STM32Cube HAL:NAND 1.7.13, Device:STM32Cube HAL:PWR 1.7.13, Device:STM32Cube HAL:RCC 1.7.13, Device:STM32Cube HAL:TIM 1.7.13, Device:STM32Cube HAL:UART 1.7.13, Device:Startup 2.6.3
